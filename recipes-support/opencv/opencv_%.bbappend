PACKAGECONFIG:append = " dnn"